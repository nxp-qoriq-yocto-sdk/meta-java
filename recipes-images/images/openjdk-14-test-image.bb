IMAGE_INSTALL_append = " openjdk-14 "

inherit openjdk-test-image
