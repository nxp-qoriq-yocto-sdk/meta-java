IMAGE_INSTALL_append = " openjre-14 "

inherit openjre-test-image
