# Copyright (C) 2020 Richard Leitner <richard.leitner@skidata.com>
# Released under the MIT license (see COPYING.MIT for the terms)

require openjdk-14-common.inc
require openjdk-14-release.inc
